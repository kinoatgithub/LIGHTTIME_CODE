# Keil uVision project LT_CODE_V0.0.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: LT_CODE_V0.0.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER
  group Source Group 1
    ./: STARTUP.A51
    ./USER/: MAIN.C MOTO_DRIVER.C SWITCH.C TIME_COUNTING.C
